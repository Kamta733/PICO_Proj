v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {component/Reduntant_Inverter/Redn_INV.sym} -20 20 0 0 {name=x1}
