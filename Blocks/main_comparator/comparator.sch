v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 40230 -34510 40230 -34460 {
lab=#net1}
N 40130 -34460 40130 -34430 {
lab=#net1}
N 40130 -34460 40150 -34460 {
lab=#net1}
N 40320 -34460 40320 -34430 {
lab=#net1}
N 40130 -34370 40130 -34360 {
lab=#net2}
N 40130 -34370 40130 -34320 {
lab=#net2}
N 40040 -34320 40130 -34320 {
lab=#net2}
N 40040 -34320 40040 -34290 {
lab=#net2}
N 40410 -34320 40410 -34290 {
lab=#net3}
N 40320 -34320 40410 -34320 {
lab=#net3}
N 40320 -34370 40320 -34320 {
lab=#net3}
N 40280 -34400 40280 -34100 {
lab=Out-}
N 40280 -34100 40310 -34100 {
lab=Out-}
N 40220 -34100 40240 -34100 {
lab=Out+}
N 40240 -34400 40240 -34100 {
lab=Out+}
N 40170 -34400 40240 -34400 {
lab=Out+}
N 40410 -34230 40410 -34210 {
lab=Out+}
N 40240 -34210 40410 -34210 {
lab=Out+}
N 40040 -34230 40040 -34190 {
lab=Out-}
N 40040 -34190 40280 -34190 {
lab=Out-}
N 40180 -34160 40180 -34130 {
lab=Out-}
N 40010 -34160 40180 -34160 {
lab=Out-}
N 40010 -34160 40010 -34130 {
lab=Out-}
N 40550 -34150 40550 -34130 {
lab=Out+}
N 40350 -34150 40550 -34150 {
lab=Out+}
N 40350 -34150 40350 -34130 {
lab=Out+}
N 40550 -34070 40550 -34030 {
lab=GND}
N 40350 -34030 40550 -34030 {
lab=GND}
N 40350 -34070 40350 -34030 {
lab=GND}
N 40180 -34070 40180 -34010 {
lab=GND}
N 40010 -34010 40180 -34010 {
lab=GND}
N 40010 -34070 40010 -34010 {
lab=GND}
N 40110 -34100 40180 -34100 {
lab=GND}
N 40180 -34050 40190 -34050 {
lab=GND}
N 40010 -34100 40080 -34100 {
lab=GND}
N 40000 -34040 40010 -34040 {
lab=GND}
N 40450 -34030 40450 -33940 {
lab=GND}
N 40100 -33940 40450 -33940 {
lab=GND}
N 40100 -34010 40100 -33940 {
lab=GND}
N 40100 -34010 40110 -34010 {
lab=GND}
N 40450 -34260 40530 -34260 {
lab=O1+}
N 40530 -34500 40530 -34260 {
lab=O1+}
N 40520 -34500 40530 -34500 {
lab=O1+}
N 39960 -34260 40000 -34260 {
lab=O1-}
N 39960 -34540 39960 -34260 {
lab=O1-}
N 40590 -34100 40630 -34100 {
lab=#net4}
N 39870 -34100 39970 -34100 {
lab=#net4}
N 40320 -34400 40410 -34400 {
lab=Vdd}
N 40320 -34460 40410 -34460 {
lab=#net1}
N 40010 -34400 40130 -34400 {
lab=Vdd}
N 40010 -34460 40150 -34460 {
lab=#net1}
N 40140 -34460 40320 -34460 {
lab=#net1}
N 40130 -34460 40140 -34460 {
lab=#net1}
N 40410 -34210 40410 -34150 {
lab=Out+}
N 40090 -34190 40090 -34160 {
lab=Out-}
N 40040 -34260 40140 -34260 {
lab=Vdd}
N 40130 -34320 40140 -34320 {
lab=#net2}
N 40330 -34260 40420 -34260 {
lab=Vdd}
N 40350 -34100 40400 -34100 {
lab=GND}
N 40510 -34100 40550 -34100 {
lab=GND}
N 40230 -34540 40310 -34540 {
lab=Vdd}
N 40310 -34580 40310 -34540 {
lab=Vdd}
N 40290 -34580 40310 -34580 {
lab=Vdd}
N 40230 -34580 40290 -34580 {
lab=Vdd}
N 40230 -34580 40230 -34570 {
lab=Vdd}
N 40230 -34660 40230 -34570 {
lab=Vdd}
N 40170 -35460 40170 -35410 {
lab=#net5}
N 40170 -35410 40370 -35410 {
lab=#net5}
N 40370 -35410 40370 -35390 {
lab=#net5}
N 39980 -35410 40170 -35410 {
lab=#net5}
N 39980 -35410 39980 -35370 {
lab=#net5}
N 40370 -35330 40370 -34970 {
lab=O1+}
N 39980 -35310 39980 -34970 {
lab=O1-}
N 40090 -35130 40290 -35130 {
lab=#net6}
N 40180 -35130 40180 -35100 {
lab=#net6}
N 40070 -35070 40140 -35070 {
lab=Vdd}
N 40090 -35230 40090 -35190 {
lab=O1+}
N 40090 -35230 40370 -35230 {
lab=O1+}
N 40290 -35250 40290 -35190 {
lab=O1-}
N 39980 -35250 40290 -35250 {
lab=O1-}
N 39980 -35160 40050 -35160 {
lab=O1-}
N 40330 -35160 40370 -35160 {
lab=O1+}
N 40170 -35600 40170 -35520 {
lab=Vdd}
N 40080 -35490 40130 -35490 {
lab=#net7}
N 39980 -34910 39980 -34880 {
lab=GND}
N 40370 -34910 40370 -34880 {
lab=GND}
N 40180 -35040 40180 -35020 {
lab=GND}
N 39920 -35340 39940 -35340 {
lab=Vin+}
N 40410 -35360 40450 -35360 {
lab=Vin-}
N 40370 -35230 40540 -35230 {
lab=O1+}
N 39800 -35250 39980 -35250 {
lab=O1-}
N 39840 -34490 39960 -34490 {
lab=O1-}
N 39840 -35250 39840 -34490 {
lab=O1-}
N 40530 -34480 40590 -34480 {
lab=O1+}
N 40590 -35160 40590 -34480 {
lab=O1+}
N 40490 -35160 40590 -35160 {
lab=O1+}
N 40490 -35230 40490 -35160 {
lab=O1+}
N 40110 -34540 40190 -34540 {
lab=#net8}
N 40100 -34540 40110 -34540 {
lab=#net8}
N 39750 -34190 40040 -34190 {
lab=Out-}
N 40410 -34180 40650 -34180 {
lab=Out+}
N 41660 -34880 41820 -34880 {
lab=#net9}
N 42450 -34880 42490 -34880 {
lab=#net7}
N 41490 -34880 41580 -34880 {
lab=#net4}
N 41530 -34880 41530 -34660 {
lab=#net4}
N 41610 -34850 41610 -34800 {
lab=GND}
N 41610 -34800 42400 -34800 {
lab=GND}
N 42400 -34850 42400 -34800 {
lab=GND}
N 42110 -34850 42110 -34840 {
lab=GND}
N 42120 -34850 42120 -34800 {
lab=GND}
N 42110 -34850 42120 -34850 {
lab=GND}
N 41850 -34850 41850 -34800 {
lab=GND}
N 41850 -34950 41850 -34910 {
lab=Vdd}
N 41610 -34950 41850 -34950 {
lab=Vdd}
N 41610 -34950 41610 -34910 {
lab=Vdd}
N 41850 -34950 42110 -34950 {
lab=Vdd}
N 42110 -34950 42110 -34910 {
lab=Vdd}
N 42110 -34950 42400 -34950 {
lab=Vdd}
N 42400 -34950 42400 -34910 {
lab=Vdd}
N 39980 -35340 40070 -35340 {
lab=Vdd}
N 40270 -35360 40370 -35360 {
lab=Vdd}
N 40090 -35160 40150 -35160 {
lab=GND}
N 40250 -35160 40290 -35160 {
lab=GND}
N 40180 -35070 40260 -35070 {
lab=GND}
N 41900 -34880 42080 -34880 {
lab=#net10}
N 42160 -34880 42370 -34880 {
lab=#net11}
N 40370 -34940 40490 -34940 {
lab=GND}
N 39910 -34940 39980 -34940 {
lab=GND}
N 40170 -35490 40260 -35490 {
lab=Vdd}
N 40260 -35540 40260 -35490 {
lab=Vdd}
N 40170 -35540 40260 -35540 {
lab=Vdd}
N 40020 -34940 40330 -34940 {
lab=#net4}
N 41910 -34680 42500 -34680 {
lab=#net8}
N 41530 -34660 41760 -34660 {
lab=#net4}
N 41690 -34690 41760 -34690 {
lab=GND}
N 41680 -34800 41680 -34690 {
lab=GND}
N 41680 -34690 41690 -34690 {
lab=GND}
N 40090 -35680 40090 -35490 {
lab=#net7}
N 40090 -35680 42690 -35680 {
lab=#net7}
N 42490 -34880 42590 -34880 {
lab=#net7}
N 42590 -35680 42590 -34880 {
lab=#net7}
N 41200 -34880 41490 -34880 {
lab=#net4}
N 41200 -34880 41200 -34870 {
lab=#net4}
N 40630 -34100 41290 -34100 {
lab=#net4}
N 41290 -34660 41290 -34100 {
lab=#net4}
N 41290 -34660 41530 -34660 {
lab=#net4}
N 39910 -34100 39910 -33790 {
lab=#net4}
N 39910 -33790 40860 -33790 {
lab=#net4}
N 40860 -34100 40860 -33790 {
lab=#net4}
N 39460 -34810 40220 -34810 {
lab=#net4}
N 40220 -34930 40220 -34810 {
lab=#net4}
N 40220 -34940 40220 -34930 {
lab=#net4}
N 39390 -33790 39930 -33790 {
lab=#net4}
N 39390 -34800 39390 -33790 {
lab=#net4}
N 39390 -34810 39460 -34810 {
lab=#net4}
N 39390 -34810 39390 -34760 {
lab=#net4}
N 42500 -34680 42500 -34360 {
lab=#net8}
N 40810 -34360 42500 -34360 {
lab=#net8}
N 40810 -34710 40810 -34360 {
lab=#net8}
N 40120 -34710 40810 -34710 {
lab=#net8}
N 40120 -34710 40120 -34540 {
lab=#net8}
C {sky130_fd_pr/pfet_01v8.sym} 40210 -34540 0 0 {name=M1
L=1
W=0.55
ad="'W * 0.29'" pd="'W + 2 * 0.29'"
as="'W * 0.29'" ps="'W + 2 * 0.29'"
nrd=0 nrs=0
sa=0 sb=0 sd=0
nf=1 mult=1
model=pfet_01v8
spiceprefix=X
 }
C {sky130_fd_pr/pfet_01v8.sym} 40150 -34400 0 1 {name=M2
L=1
W=0.55
ad="'W * 0.29'" pd="'W + 2 * 0.29'"
as="'W * 0.29'" ps="'W + 2 * 0.29'"
nrd=0 nrs=0
sa=0 sb=0 sd=0
nf=1 mult=1
model=pfet_01v8
spiceprefix=X
 }
C {sky130_fd_pr/pfet_01v8.sym} 40300 -34400 0 0 {name=M3
L=1
W=0.55
ad="'W * 0.29'" pd="'W + 2 * 0.29'"
as="'W * 0.29'" ps="'W + 2 * 0.29'"
nrd=0 nrs=0
sa=0 sb=0 sd=0
nf=1 mult=1
model=pfet_01v8
spiceprefix=X
 }
C {sky130_fd_pr/pfet_01v8.sym} 40020 -34260 0 0 {name=M5
L=1
W=0.55
ad="'W * 0.29'" pd="'W + 2 * 0.29'"
as="'W * 0.29'" ps="'W + 2 * 0.29'"
nrd=0 nrs=0
sa=0 sb=0 sd=0
nf=1 mult=1
model=pfet_01v8
spiceprefix=X
 }
C {sky130_fd_pr/pfet_01v8.sym} 40430 -34260 0 1 {name=M6
L=1
W=0.55
ad="'W * 0.29'" pd="'W + 2 * 0.29'"
as="'W * 0.29'" ps="'W + 2 * 0.29'"
nrd=0 nrs=0
sa=0 sb=0 sd=0
nf=1 mult=1
model=pfet_01v8
spiceprefix=X
 }
C {sky130_fd_pr/nfet_01v8_lvt.sym} 39990 -34100 0 0 {name=M7
L=1
W=1
ad="'W * 0.29'" pd="'2*(W + 0.29)'"
as="'W * 0.29'" ps="'2*(W + 0.29)'"
nrd=0 nrs=0
sa=0 sb=0 sd=0
nf=1 mult=1
model=nfet_01v8_lvt
spiceprefix=X
 }
C {sky130_fd_pr/nfet_01v8_lvt.sym} 40330 -34100 0 0 {name=M10
L=1
W=1
ad="'W * 0.29'" pd="'2*(W + 0.29)'"
as="'W * 0.29'" ps="'2*(W + 0.29)'"
nrd=0 nrs=0
sa=0 sb=0 sd=0
nf=1 mult=1
model=nfet_01v8_lvt
spiceprefix=X
 }
C {sky130_fd_pr/nfet_01v8_lvt.sym} 40200 -34100 0 1 {name=M8
L=1
W=1
ad="'W * 0.29'" pd="'2*(W + 0.29)'"
as="'W * 0.29'" ps="'2*(W + 0.29)'"
nrd=0 nrs=0
sa=0 sb=0 sd=0
nf=1 mult=1
model=nfet_01v8_lvt
spiceprefix=X
 }
C {sky130_fd_pr/nfet_01v8_lvt.sym} 40570 -34100 0 1 {name=M9
L=1
W=1
ad="'W * 0.29'" pd="'2*(W + 0.29)'"
as="'W * 0.29'" ps="'2*(W + 0.29)'"
nrd=0 nrs=0
sa=0 sb=0 sd=0
nf=1 mult=1
model=nfet_01v8_lvt
spiceprefix=X
 }
C {devices/lab_pin.sym} 40230 -34650 0 0 {name=l1 sig_type=std_logic lab=Vdd
}
C {devices/gnd.sym} 40300 -33940 0 0 {name=l2 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 40350 -34940 0 0 {name=M4
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 40000 -34940 0 1 {name=M11
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 40310 -35160 0 1 {name=M12
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 40070 -35160 0 0 {name=M13
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 40160 -35070 0 0 {name=M14
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 39960 -35340 0 0 {name=M15
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 40390 -35360 0 1 {name=M16
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 40150 -35490 0 0 {name=M17
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/code.sym} 40510 -35550 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {devices/gnd.sym} 39980 -34880 0 0 {name=l3 lab=GND}
C {devices/gnd.sym} 40370 -34880 0 0 {name=l4 lab=GND}
C {devices/gnd.sym} 40180 -35020 0 0 {name=l5 lab=GND}
C {devices/ipin.sym} 39920 -35340 0 0 {name=p4 lab=Vin+}
C {devices/ipin.sym} 40450 -35360 0 1 {name=p5 lab=Vin-}
C {devices/opin.sym} 40540 -35230 0 0 {name=p6 lab=O1+
}
C {devices/opin.sym} 39800 -35250 2 0 {name=p7 lab=O1-}
C {devices/lab_pin.sym} 40170 -35600 0 0 {name=l6 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 40070 -35070 0 0 {name=l7 sig_type=std_logic lab=Vdd}
C {devices/opin.sym} 40640 -34180 2 1 {name=p9 lab=Out+}
C {devices/opin.sym} 39760 -34190 2 0 {name=p10 lab=Out-}
C {devices/lab_pin.sym} 41920 -34950 1 0 {name=l8 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} 42020 -34800 0 0 {name=l9 lab=GND}
C {devices/vsource.sym} 41360 -35020 0 0 {name=V1 value=1v}
C {devices/lab_pin.sym} 41360 -35050 0 0 {name=l10 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} 41360 -34990 0 0 {name=l11 lab=GND}
C {devices/vsource.sym} 40710 -35360 0 0 {name=V4 value=200mv}
C {devices/lab_pin.sym} 40710 -35390 0 0 {name=l16 sig_type=std_logic lab=Vin-}
C {devices/gnd.sym} 40710 -35330 0 0 {name=l17 lab=GND}
C {devices/vsource.sym} 39650 -35370 0 0 {name=V3 value=400mv}
C {devices/lab_pin.sym} 39650 -35400 0 0 {name=l14 sig_type=std_logic lab=Vin+}
C {devices/gnd.sym} 39650 -35340 0 0 {name=l15 lab=GND}
C {devices/code_shown.sym} 41380 -34140 0 0 {name=SPICE
only_toplevel=true
value="
.tran 0.01n 140n
.save all
"}
C {devices/lab_pin.sym} 40070 -35340 1 0 {name=l18 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 40270 -35360 1 0 {name=l19 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 40020 -34400 1 0 {name=l21 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 40410 -34400 1 0 {name=l22 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 40140 -34260 1 0 {name=l23 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 40330 -34260 1 0 {name=l24 sig_type=std_logic lab=Vdd
}
C {devices/gnd.sym} 40070 -34100 0 0 {name=l25 lab=GND}
C {devices/gnd.sym} 40120 -34100 0 0 {name=l26 lab=GND}
C {devices/gnd.sym} 40400 -34100 0 0 {name=l27 lab=GND}
C {devices/gnd.sym} 40510 -34100 0 0 {name=l28 lab=GND}
C {devices/gnd.sym} 40150 -35160 0 0 {name=l29 lab=GND}
C {devices/gnd.sym} 40250 -35160 0 0 {name=l30 lab=GND}
C {devices/gnd.sym} 40490 -34940 0 0 {name=l32 lab=GND}
C {devices/gnd.sym} 39910 -34940 0 0 {name=l33 lab=GND}
C {devices/gnd.sym} 40260 -35070 0 0 {name=l20 lab=GND}
C {pico/main_comparator/OR_gate/a1.sym} 41680 -34660 0 0 {}
C {devices/lab_pin.sym} 41840 -34720 1 0 {name=l31 sig_type=std_logic lab=Vdd}
C {devices/vsource.sym} 41200 -34840 0 0 {name=V2 value="pulse(0 1.2 0 1p 1p 50u 140u)"}
C {devices/gnd.sym} 41200 -34810 0 0 {name=l13 lab=GND}
C {pico/main_comparator/inverter/INV.sym} 41560 -34880 0 0 {name=x1}
C {pico/main_comparator/inverter/INV.sym} 41800 -34880 0 0 {name=x2}
C {pico/main_comparator/inverter/INV.sym} 42060 -34880 0 0 {name=x3}
C {pico/main_comparator/inverter/INV.sym} 42350 -34880 0 0 {name=x4}
