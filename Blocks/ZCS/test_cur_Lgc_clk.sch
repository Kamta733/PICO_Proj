v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1830 -1460 1830 -1390 {
lab=G1}
N 1840 -1310 1910 -1310 {
lab=G1}
N 2900 -1100 2900 -1070 {
lab=GND}
N 2900 -1360 2900 -1160 {
lab=Vdd}
N 1800 -1390 1800 -1340 {
lab=G1}
N 1800 -1390 1830 -1390 {
lab=G1}
N 1880 -1410 1880 -1310 {
lab=G1}
N 1830 -1410 1880 -1410 {
lab=G1}
N 1910 -1310 1910 -1300 {
lab=G1}
N 2110 -1270 2110 -1260 {
lab=GND}
N 2110 -1260 2110 -1220 {
lab=GND}
N 2110 -1410 2110 -1330 {
lab=G2}
N 2150 -1440 2180 -1440 {
lab=G2}
N 2110 -1500 2110 -1470 {
lab=Vdd}
N 2180 -1460 2180 -1440 {
lab=G2}
N 2390 -1580 2390 -1490 {
lab=Vdd}
N 2110 -1580 2390 -1580 {
lab=Vdd}
N 2110 -1580 2110 -1500 {
lab=Vdd}
N 2300 -930 2350 -930 {
lab=G1}
N 2300 -1070 2300 -930 {
lab=G1}
N 2390 -870 2470 -870 {
lab=GND}
N 2390 -900 2390 -870 {
lab=GND}
N 2430 -870 2430 -840 {
lab=GND}
N 2390 -1230 2390 -1170 {
lab=#net1}
N 2340 -1260 2350 -1260 {
lab=#net2}
N 1800 -1280 1800 -1240 {
lab=GND}
N 1800 -1250 1840 -1250 {
lab=GND}
N 1980 -1070 2300 -1070 {
lab=G1}
N 1830 -1560 1830 -1520 {
lab=Vdd}
N 1830 -1560 2110 -1560 {
lab=Vdd}
N 2390 -1020 2670 -1020 {
lab=D3}
N 1960 -1340 1960 -1300 {
lab=G1}
N 2230 -1500 2230 -1460 {
lab=G2}
N 2620 -1200 2620 -1180 {
lab=D2}
N 2110 -1370 2220 -1370 {
lab=G2}
N 2220 -1460 2220 -1370 {
lab=G2}
N 1910 -1300 2010 -1300 {
lab=G1}
N 1980 -1300 1980 -1210 {
lab=G1}
N 2390 -1340 2390 -1290 {
lab=D1}
N 2390 -1370 2390 -1340 {
lab=D1}
N 2560 -1200 2620 -1200 {
lab=D2}
N 2390 -1200 2500 -1200 {
lab=#net1}
N 2390 -1050 2390 -960 {
lab=D3}
N 1980 -1160 1980 -1070 {
lab=G1}
N 2180 -1460 2290 -1460 {
lab=G2}
N 1980 -1220 1980 -1150 {
lab=G1}
N 2320 -1140 2350 -1140 {
lab=#net3}
N 1190 -1720 1190 -1690 {
lab=Vin+}
N 1190 -1630 1190 -1590 {
lab=GND}
N 1370 -1720 1370 -1690 {
lab=Vin-}
N 1370 -1630 1370 -1590 {
lab=GND}
N 1640 -2170 1690 -2170 {
lab=#net4}
N 1790 -2170 1840 -2170 {
lab=#net5}
N 1940 -2170 1990 -2170 {
lab=#net6}
N 2090 -2170 2140 -2170 {
lab=#net7}
N 2240 -2170 2290 -2170 {
lab=#net8}
N 1580 -2250 1580 -2210 {
lab=Vdd}
N 1580 -2250 1730 -2250 {
lab=Vdd}
N 1730 -2250 2330 -2250 {
lab=Vdd}
N 2330 -2250 2330 -2210 {
lab=Vdd}
N 2180 -2250 2180 -2210 {
lab=Vdd}
N 2030 -2250 2030 -2210 {
lab=Vdd}
N 1880 -2250 1880 -2210 {
lab=Vdd}
N 1730 -2250 1730 -2210 {
lab=Vdd}
N 1540 -2250 1580 -2250 {
lab=Vdd}
N 1540 -2290 1540 -2250 {
lab=Vdd}
N 1580 -2130 1580 -2090 {
lab=GND}
N 1580 -2090 2330 -2090 {
lab=GND}
N 2330 -2130 2330 -2090 {
lab=GND}
N 2180 -2130 2180 -2090 {
lab=GND}
N 2030 -2130 2030 -2090 {
lab=GND}
N 1880 -2130 1880 -2090 {
lab=GND}
N 1730 -2130 1730 -2090 {
lab=GND}
N 1960 -2090 1960 -2050 {
lab=GND}
N 2260 -2170 2260 -1990 {
lab=#net8}
N 1530 -1990 2260 -1990 {
lab=#net8}
N 1530 -2170 1530 -1990 {
lab=#net8}
N 1530 -2170 1540 -2170 {
lab=#net8}
N 2390 -2170 2420 -2170 {
lab=Clkcheck}
N 2420 -2170 2480 -2170 {
lab=Clkcheck}
N 2520 -2220 2520 -2200 {
lab=Vdd}
N 2510 -2140 2510 -2120 {
lab=Vdd}
N 2530 -2140 2530 -2120 {
lab=GND}
N 2560 -2170 2590 -2170 {
lab=Clk}
N 970 -790 970 -750 {
lab=Vdd}
N 1100 -720 1200 -720 {
lab=#net2}
N 970 -680 970 -650 {
lab=GND}
N 790 -730 870 -730 {
lab=#net9}
N 790 -790 790 -730 {
lab=#net9}
N 750 -790 790 -790 {
lab=#net9}
N 520 -710 520 -430 {
lab=Out+}
N 520 -710 950 -710 {
lab=Out+}
N 400 -790 670 -790 {
lab=Out+}
N 700 -900 700 -820 {
lab=Vdd}
N 1020 -720 1120 -720 {
lab=#net2}
N 520 -430 520 -420 {
lab=Out+}
N 870 -730 950 -730 {
lab=#net9}
N 1530 -450 1530 -430 {
lab=#net3}
N 1530 -450 1680 -450 {
lab=#net3}
N 1680 -450 1680 -430 {
lab=#net3}
N 1600 -510 1600 -450 {
lab=#net3}
N 1600 -600 1600 -570 {
lab=#net10}
N 1530 -370 1530 -330 {
lab=GND}
N 1530 -330 1680 -330 {
lab=GND}
N 1680 -360 1680 -330 {
lab=GND}
N 1610 -330 1610 -290 {
lab=GND}
N 1470 -540 1560 -540 {
lab=Out+}
N 1470 -540 1470 -400 {
lab=Out+}
N 1470 -400 1490 -400 {
lab=Out+}
N 1570 -400 1640 -400 {
lab=#net9}
N 1570 -470 1570 -400 {
lab=#net9}
N 1540 -470 1570 -470 {
lab=#net9}
N 1540 -630 1540 -470 {
lab=#net9}
N 1540 -630 1560 -630 {
lab=#net9}
N 1440 -540 1470 -540 {
lab=Out+}
N 1420 -540 1440 -540 {
lab=Out+}
N 1600 -630 1620 -630 {
lab=Vdd}
N 1620 -690 1620 -630 {
lab=Vdd}
N 1600 -690 1600 -660 {
lab=Vdd}
N 1620 -630 1620 -540 {
lab=Vdd}
N 1600 -540 1620 -540 {
lab=Vdd}
N 1530 -400 1540 -400 {
lab=GND}
N 1540 -400 1540 -360 {
lab=GND}
N 1530 -360 1540 -360 {
lab=GND}
N 1680 -400 1700 -400 {
lab=GND}
N 1700 -400 1700 -360 {
lab=GND}
N 1680 -360 1700 -360 {
lab=GND}
N 1680 -370 1680 -360 {
lab=GND}
N 1600 -690 1620 -690 {
lab=Vdd}
N 1600 -710 1600 -690 {
lab=Vdd}
N 1600 -480 1750 -480 {
lab=#net3}
N 1680 -330 1780 -330 {
lab=GND}
N 520 -540 1430 -540 {
lab=Out+}
N 790 -730 790 -600 {
lab=#net9}
N 790 -600 790 -590 {
lab=#net9}
N -50 -600 520 -600 {
lab=Out+}
N -50 -630 420 -630 {
lab=Out+}
N 420 -790 420 -630 {
lab=Out+}
N 2070 -1140 2330 -1140 {
lab=#net3}
N 2070 -1140 2070 -490 {
lab=#net3}
N 1730 -490 2070 -490 {
lab=#net3}
N 1740 -490 1740 -480 {
lab=#net3}
N 2260 -1260 2350 -1260 {
lab=#net2}
N 2260 -1260 2260 -1180 {
lab=#net2}
N 1180 -1180 2260 -1180 {
lab=#net2}
N 1180 -1180 1180 -720 {
lab=#net2}
N -920 -1890 -920 -1840 {
lab=#net11}
N -920 -1840 -720 -1840 {
lab=#net11}
N -720 -1840 -720 -1820 {
lab=#net11}
N -1110 -1840 -920 -1840 {
lab=#net11}
N -1110 -1840 -1110 -1800 {
lab=#net11}
N -720 -1760 -720 -1400 {
lab=O1+}
N -1110 -1740 -1110 -1400 {
lab=O1-}
N -1070 -1370 -760 -1370 {
lab=Clk}
N -1000 -1560 -800 -1560 {
lab=#net12}
N -910 -1560 -910 -1530 {
lab=#net12}
N -1020 -1500 -950 -1500 {
lab=Vdd}
N -1000 -1660 -1000 -1620 {
lab=O1+}
N -1000 -1660 -720 -1660 {
lab=O1+}
N -800 -1680 -800 -1620 {
lab=O1-}
N -1110 -1680 -800 -1680 {
lab=O1-}
N -1110 -1590 -1040 -1590 {
lab=O1-}
N -760 -1590 -720 -1590 {
lab=O1+}
N -920 -2030 -920 -1950 {
lab=Vdd}
N -1010 -1920 -960 -1920 {
lab=Clkb1}
N -1110 -1340 -1110 -1310 {
lab=GND}
N -720 -1340 -720 -1310 {
lab=GND}
N -910 -1470 -910 -1450 {
lab=GND}
N -1170 -1770 -1150 -1770 {
lab=Vin+}
N -680 -1790 -640 -1790 {
lab=Vin-}
N -720 -1660 -550 -1660 {
lab=O1+}
N -1290 -1680 -1110 -1680 {
lab=O1-}
N -920 -1370 -920 -1330 {
lab=Clk}
N -920 -1970 -890 -1970 {
lab=Vdd}
N -890 -1970 -890 -1920 {
lab=Vdd}
N -920 -1920 -890 -1920 {
lab=Vdd}
N -1080 -1810 -1080 -1770 {
lab=Vdd}
N -1110 -1770 -1080 -1770 {
lab=Vdd}
N -740 -1830 -740 -1790 {
lab=Vdd}
N -740 -1790 -720 -1790 {
lab=Vdd}
N -1000 -1590 -990 -1590 {
lab=GND}
N -820 -1590 -800 -1590 {
lab=GND}
N -910 -1460 -900 -1460 {
lab=GND}
N -900 -1500 -900 -1460 {
lab=GND}
N -910 -1500 -900 -1500 {
lab=GND}
N -1140 -1370 -1110 -1370 {
lab=GND}
N -1140 -1370 -1140 -1320 {
lab=GND}
N -1140 -1320 -1110 -1320 {
lab=GND}
N -720 -1370 -700 -1370 {
lab=GND}
N -700 -1370 -700 -1330 {
lab=GND}
N -720 -1330 -700 -1330 {
lab=GND}
N -990 -1590 -990 -1540 {
lab=GND}
N -820 -1590 -820 -1540 {
lab=GND}
N -1910 -1500 -1800 -1500 {
lab=#net13}
N -1720 -1500 -1620 -1500 {
lab=#net14}
N -2170 -1560 -2170 -1530 {
lab=Vdd}
N -1960 -1560 -1960 -1530 {
lab=Vdd}
N -1770 -1560 -1770 -1530 {
lab=Vdd}
N -1590 -1560 -1590 -1530 {
lab=Vdd}
N -2330 -1500 -2200 -1500 {
lab=Clk}
N -2250 -1500 -2250 -1300 {
lab=Clk}
N -1540 -1500 -1440 -1500 {
lab=Clkb2}
N -2170 -1470 -2170 -1450 {
lab=GND}
N -1960 -1470 -1960 -1450 {
lab=GND}
N -1770 -1470 -1770 -1450 {
lab=GND}
N -1590 -1470 -1590 -1450 {
lab=GND}
N -900 -940 -900 -890 {
lab=#net15}
N -1000 -890 -1000 -860 {
lab=#net15}
N -810 -890 -810 -860 {
lab=#net15}
N -1000 -800 -1000 -790 {
lab=#net16}
N -1000 -800 -1000 -750 {
lab=#net16}
N -1090 -750 -1000 -750 {
lab=#net16}
N -1090 -750 -1090 -720 {
lab=#net16}
N -720 -750 -720 -720 {
lab=#net17}
N -810 -750 -720 -750 {
lab=#net17}
N -810 -800 -810 -750 {
lab=#net17}
N -850 -830 -850 -530 {
lab=Out-}
N -850 -530 -820 -530 {
lab=Out-}
N -910 -530 -890 -530 {
lab=Out+}
N -890 -830 -890 -530 {
lab=Out+}
N -960 -830 -890 -830 {
lab=Out+}
N -720 -660 -720 -640 {
lab=Out+}
N -890 -640 -720 -640 {
lab=Out+}
N -1090 -660 -1090 -620 {
lab=Out-}
N -1090 -620 -850 -620 {
lab=Out-}
N -950 -590 -950 -560 {
lab=Out-}
N -1120 -590 -950 -590 {
lab=Out-}
N -1120 -590 -1120 -560 {
lab=Out-}
N -580 -580 -580 -560 {
lab=Out+}
N -780 -580 -580 -580 {
lab=Out+}
N -780 -580 -780 -560 {
lab=Out+}
N -580 -500 -580 -460 {
lab=GND}
N -780 -460 -580 -460 {
lab=GND}
N -780 -500 -780 -460 {
lab=GND}
N -950 -500 -950 -440 {
lab=GND}
N -1120 -500 -1120 -440 {
lab=GND}
N -1020 -530 -950 -530 {
lab=GND}
N -1120 -530 -1050 -530 {
lab=GND}
N -680 -460 -680 -370 {
lab=GND}
N -1030 -370 -680 -370 {
lab=GND}
N -1030 -440 -1030 -370 {
lab=GND}
N -680 -690 -600 -690 {
lab=O1+}
N -1170 -690 -1130 -690 {
lab=O1-}
N -540 -530 -500 -530 {
lab=Clk}
N -1260 -530 -1160 -530 {
lab=Clk}
N -810 -830 -720 -830 {
lab=Vdd}
N -1120 -830 -1000 -830 {
lab=Vdd}
N -720 -640 -720 -580 {
lab=Out+}
N -1040 -620 -1040 -590 {
lab=Out-}
N -1090 -690 -990 -690 {
lab=Vdd}
N -1000 -750 -990 -750 {
lab=#net16}
N -800 -690 -710 -690 {
lab=Vdd}
N -780 -530 -730 -530 {
lab=GND}
N -620 -530 -580 -530 {
lab=GND}
N -900 -970 -820 -970 {
lab=Vdd}
N -820 -1010 -820 -970 {
lab=Vdd}
N -840 -1010 -820 -1010 {
lab=Vdd}
N -900 -1010 -840 -1010 {
lab=Vdd}
N -900 -1010 -900 -1000 {
lab=Vdd}
N -900 -1090 -900 -1000 {
lab=Vdd}
N -1020 -970 -940 -970 {
lab=Clkb2}
N -1030 -970 -1020 -970 {
lab=Clkb2}
N -1380 -620 -1090 -620 {
lab=Out-}
N -720 -610 -480 -610 {
lab=Out+}
N -1000 -890 -810 -890 {
lab=#net15}
N -1250 -1680 -1250 -690 {
lab=O1-}
N -1250 -690 -1170 -690 {
lab=O1-}
N -600 -1660 -600 -920 {
lab=O1+}
N -600 -920 -600 -690 {
lab=O1+}
N -1120 -440 -950 -440 {
lab=GND}
N -2250 -1300 -2250 -1270 {
lab=Clk}
N -1850 -1070 -1850 -990 {
lab=#net18}
N -1850 -990 -1840 -990 {
lab=#net18}
N -1840 -990 -1840 -980 {
lab=#net18}
N -1840 -990 -1660 -990 {
lab=#net18}
N -1660 -990 -1660 -980 {
lab=#net18}
N -1850 -1180 -1850 -1130 {
lab=#net19}
N -1850 -1300 -1850 -1240 {
lab=Vdd}
N -1840 -920 -1840 -900 {
lab=GND}
N -1840 -900 -1660 -900 {
lab=GND}
N -1660 -920 -1660 -900 {
lab=GND}
N -1760 -900 -1760 -880 {
lab=GND}
N -1980 -1210 -1890 -1210 {
lab=Inv}
N -1980 -1100 -1890 -1100 {
lab=Clk}
N -1960 -950 -1880 -950 {
lab=Clk}
N -1960 -1100 -1960 -950 {
lab=Clk}
N -1730 -950 -1700 -950 {
lab=Inv}
N -1730 -950 -1730 -870 {
lab=Inv}
N -1730 -870 -1730 -790 {
lab=Inv}
N -2030 -790 -1730 -790 {
lab=Inv}
N -2030 -1200 -2030 -790 {
lab=Inv}
N -2030 -1210 -2030 -1200 {
lab=Inv}
N -2030 -1210 -1980 -1210 {
lab=Inv}
N -1850 -1210 -1740 -1210 {
lab=Vdd}
N -1850 -1100 -1740 -1100 {
lab=Vdd}
N -1840 -950 -1790 -950 {
lab=GND}
N -1660 -950 -1560 -950 {
lab=GND}
N -1790 -950 -1790 -900 {
lab=GND}
N -1560 -950 -1560 -870 {
lab=GND}
N -1700 -870 -1560 -870 {
lab=GND}
N -1700 -900 -1700 -870 {
lab=GND}
N -1740 -1210 -1740 -1100 {
lab=Vdd}
N -1740 -1260 -1740 -1210 {
lab=Vdd}
N -1850 -1260 -1740 -1260 {
lab=Vdd}
N -1850 -1040 -1700 -1040 {
lab=#net18}
N -1620 -1040 -1470 -1040 {
lab=Clkb1}
N -1670 -1010 -1620 -1010 {
lab=GND}
N -1620 -1010 -1620 -1000 {
lab=GND}
N -1740 -1260 -1670 -1260 {
lab=Vdd}
N -1670 -1260 -1670 -1100 {
lab=Vdd}
N -1670 -1100 -1670 -1070 {
lab=Vdd}
N -1660 -900 -1530 -900 {
lab=GND}
N -1530 -1000 -1530 -900 {
lab=GND}
N -1620 -1000 -1530 -1000 {
lab=GND}
N -1760 -880 -1760 -870 {
lab=GND}
N -2250 -1270 -2250 -1100 {
lab=Clk}
N -2250 -1100 -1980 -1100 {
lab=Clk}
N -2110 -1250 -2060 -1250 {
lab=Inv}
N -2110 -1250 -2110 -1210 {
lab=Inv}
N -2110 -1210 -2090 -1210 {
lab=Inv}
N -2090 -1210 -2030 -1210 {
lab=Inv}
N -2120 -1500 -2080 -1500 {
lab=#net20}
N -2080 -1650 -2080 -1500 {
lab=#net20}
N -2220 -1650 -2080 -1650 {
lab=#net20}
N -2290 -1770 -2250 -1770 {
lab=#net21}
N -2020 -1640 -1940 -1640 {
lab=Inv}
N -2020 -1640 -2020 -1500 {
lab=Inv}
N -2020 -1500 -1990 -1500 {
lab=Inv}
N -2060 -1250 -2010 -1250 {
lab=Inv}
N -2010 -1500 -2010 -1250 {
lab=Inv}
N -2410 -1770 -2370 -1770 {
lab=#net20}
N -2410 -1770 -2410 -1640 {
lab=#net20}
N -2410 -1640 -2240 -1640 {
lab=#net20}
N -2240 -1650 -2240 -1640 {
lab=#net20}
N -2240 -1650 -2220 -1650 {
lab=#net20}
N -1910 -1770 -1910 -1640 {
lab=Inv}
N -1940 -1640 -1910 -1640 {
lab=Inv}
N -2170 -1770 -2130 -1770 {
lab=#net22}
N -2050 -1770 -2020 -1770 {
lab=#net23}
N -1940 -1770 -1910 -1770 {
lab=Inv}
N 790 -570 1540 -570 {
lab=#net9}
N 790 -600 790 -570 {
lab=#net9}
C {devices/gnd.sym} 1840 -1250 0 0 {name=l2 lab=GND}
C {devices/res.sym} 1830 -1490 0 0 {name=R1
value=10000K
footprint=1206
device=resistor
m=1}
C {devices/code.sym} 2570 -1730 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {devices/vsource.sym} 2900 -1130 0 0 {name=V1 value=.4v}
C {devices/gnd.sym} 2900 -1070 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 2110 -1220 0 0 {name=l5 lab=GND}
C {devices/gnd.sym} 2430 -840 0 0 {name=l6 lab=GND}
C {devices/lab_pin.sym} 2900 -1350 1 0 {name=l8 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 2200 -1580 1 0 {name=l4 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 1960 -1340 1 0 {name=l9 sig_type=std_logic lab=G1}
C {devices/lab_pin.sym} 2230 -1500 1 0 {name=l12 sig_type=std_logic lab=G2}
C {devices/lab_pin.sym} 2390 -1340 2 0 {name=l13 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} 2620 -1200 2 0 {name=l14 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} 2670 -1020 2 0 {name=l15 sig_type=std_logic lab=D3}
C {devices/capa.sym} 2620 -1150 0 0 {name=C1
m=1
value=100f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2620 -1120 0 0 {name=l3 lab=GND}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} 1820 -1310 0 1 {name=M1
L=0.35
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} 2090 -1300 0 0 {name=M3
L=0.35
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} 2370 -1140 0 0 {name=M7
L=0.35
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8_lvt.sym} 2370 -930 0 0 {name=M5
L=0.35
W=1
nf=1
mult=1
body=GND
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 2130 -1440 0 1 {name=M2
L=0.35
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 2370 -1460 0 0 {name=M4
L=0.35
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} 2370 -1260 0 0 {name=M6
L=0.35
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/ammeter.sym} 2390 -1400 0 0 {name=Vmeas1}
C {devices/ammeter.sym} 2530 -1200 3 0 {name=Vmeas2}
C {devices/ammeter.sym} 2390 -1080 0 0 {name=Vmeas3}
C {devices/ammeter.sym} 2320 -1460 3 0 {name=Vmeas4}
C {devices/ammeter.sym} 2040 -1300 3 0 {name=Vmeas5}
C {devices/vsource.sym} 1190 -1660 0 0 {name=V3 value=0.300}
C {devices/lab_pin.sym} 1190 -1720 1 0 {name=l11 sig_type=std_logic lab=Vin+}
C {devices/gnd.sym} 1190 -1590 0 0 {name=l18 lab=GND}
C {devices/vsource.sym} 1370 -1660 0 0 {name=V5 value=0.304}
C {devices/lab_pin.sym} 1370 -1720 1 0 {name=l16 sig_type=std_logic lab=Vin-}
C {devices/gnd.sym} 1370 -1590 0 0 {name=l26 lab=GND}
C {devices/code_shown.sym} 2850 -1430 0 0 {name=SPICE only_toplevel=false value=".tran 1u 5000u
.save all"}
C {devices/lab_pin.sym} 1540 -2290 1 0 {name=l43 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} 1960 -2050 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} 2520 -2220 1 0 {name=l47 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} 2510 -2120 3 0 {name=l48 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} 2530 -2120 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} 2430 -2170 1 0 {name=l50 sig_type=std_logic lab=Clkcheck}
C {component/Redn_Inv/Redn_INV.sym} 1500 -2130 0 0 {name=x3}
C {component/Redn_Inv/Redn_INV.sym} 1650 -2130 0 0 {name=x10}
C {component/Redn_Inv/Redn_INV.sym} 1800 -2130 0 0 {name=x11}
C {component/Redn_Inv/Redn_INV.sym} 1950 -2130 0 0 {name=x12}
C {component/Redn_Inv/Redn_INV.sym} 2100 -2130 0 0 {name=x13}
C {component/Redn_Inv/Redn_INV.sym} 2250 -2130 0 0 {name=x14}
C {Blocks/Divide by 3 Circuit/div3.sym} 2420 -2170 0 0 {name=x15}
C {devices/lab_pin.sym} 2580 -2170 2 0 {name=l42 sig_type=std_logic lab=Clk}
C {component/NAND2/NAND.sym} 800 -670 0 0 {name=x1}
C {devices/gnd.sym} 970 -650 0 0 {name=l7 lab=GND}
C {component/Inverter/INV.sym} 650 -790 0 0 {name=x4}
C {devices/lab_pin.sym} 700 -900 0 0 {name=l10 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} 700 -760 0 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} 970 -780 0 0 {name=l20 sig_type=std_logic lab=Vdd}
C {sky130_fd_pr/nfet_01v8.sym} 1510 -400 0 0 {name=M8
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1660 -400 0 0 {name=M9
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1580 -540 0 0 {name=M10
L=0.15
W=2.52
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1580 -630 0 0 {name=M11
L=0.15
W=2.52
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1600 -710 0 0 {name=l23 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} 1610 -290 0 0 {name=l24 lab=GND}
C {devices/gnd.sym} -1110 -1310 0 0 {name=l19 lab=GND}
C {devices/gnd.sym} -720 -1310 0 0 {name=l25 lab=GND}
C {devices/gnd.sym} -910 -1450 0 0 {name=l27 lab=GND}
C {devices/iopin.sym} -1160 -1770 0 0 {name=p2 lab=Vin+}
C {devices/iopin.sym} -650 -1790 0 1 {name=p3 lab=Vin-}
C {devices/lab_pin.sym} -1020 -1500 0 0 {name=l31 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} -990 -1540 0 0 {name=l32 lab=GND}
C {devices/gnd.sym} -820 -1540 0 0 {name=l33 lab=GND}
C {devices/lab_pin.sym} -740 -1820 0 0 {name=l34 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -1080 -1800 2 0 {name=l35 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -2170 -1560 1 0 {name=l36 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -1960 -1560 1 0 {name=l37 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -1770 -1560 1 0 {name=l38 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -1590 -1560 1 0 {name=l39 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} -2170 -1450 0 0 {name=l40 lab=GND}
C {devices/gnd.sym} -1960 -1450 0 0 {name=l41 lab=GND}
C {devices/gnd.sym} -1770 -1450 0 0 {name=l44 lab=GND}
C {devices/gnd.sym} -1590 -1450 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -900 -1090 0 0 {name=l46 sig_type=std_logic lab=Vdd
}
C {devices/gnd.sym} -830 -370 0 0 {name=l51 lab=GND}
C {devices/iopin.sym} -490 -610 2 1 {name=p9 lab=Out+}
C {devices/iopin.sym} -1370 -620 2 0 {name=p10 lab=Out-}
C {devices/lab_pin.sym} -1120 -830 1 0 {name=l52 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -720 -830 1 0 {name=l53 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -990 -690 1 0 {name=l54 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -800 -690 1 0 {name=l55 sig_type=std_logic lab=Vdd
}
C {devices/gnd.sym} -1060 -530 0 0 {name=l56 lab=GND}
C {devices/gnd.sym} -1010 -530 0 0 {name=l57 lab=GND}
C {devices/gnd.sym} -730 -530 0 0 {name=l58 lab=GND}
C {devices/gnd.sym} -620 -530 0 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -1850 -1300 1 0 {name=l60 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} -1760 -870 0 0 {name=l61 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -940 -1920 0 0 {name=M12
L=0.15
W=1.26
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -1130 -1770 0 0 {name=M13
L=0.15
W=1.26
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -700 -1790 0 1 {name=M14
L=0.15
W=1.26
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -920 -970 0 0 {name=M15
L=0.15
W=1.26
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -830 -830 0 0 {name=M16
L=0.15
W=1.26
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -1110 -690 0 0 {name=M17
L=0.15
W=1.26
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -700 -690 0 1 {name=M18
L=0.15
W=1.26
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -980 -830 0 1 {name=M19
L=0.15
W=1.26
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1020 -1590 0 0 {name=M20
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -930 -1500 0 0 {name=M21
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -780 -1590 0 1 {name=M22
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1090 -1370 0 1 {name=M23
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -740 -1370 0 0 {name=M24
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -930 -530 0 1 {name=M25
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -560 -530 0 1 {name=M26
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -800 -530 0 0 {name=M27
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1140 -530 0 0 {name=M28
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1860 -950 0 0 {name=M29
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1680 -950 0 0 {name=M30
L=0.15
W=0.42
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -1870 -1210 0 0 {name=M31
L=0.15
W=1.26
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -1870 -1100 0 0 {name=M32
L=0.15
W=1.26
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2340 -1800 1 0 {name=l62 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -2220 -1800 1 0 {name=l63 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} -2340 -1740 0 0 {name=l64 lab=GND}
C {devices/gnd.sym} -2220 -1740 0 0 {name=l65 lab=GND}
C {devices/lab_pin.sym} -2100 -1800 1 0 {name=l66 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -1990 -1800 1 0 {name=l67 sig_type=std_logic lab=Vdd}
C {devices/gnd.sym} -2100 -1740 0 0 {name=l68 lab=GND}
C {devices/gnd.sym} -1990 -1740 0 0 {name=l69 lab=GND}
C {component/black_inv_1/black_inv.sym} -2460 -1770 0 0 {name=x2}
C {component/black_inv_1/black_inv.sym} -2290 -1500 0 0 {name=x5}
C {component/black_inv_1/black_inv.sym} -2340 -1770 0 0 {name=x6}
C {component/black_inv_1/black_inv.sym} -2220 -1770 0 0 {name=x7}
C {component/black_inv_1/black_inv.sym} -2110 -1770 0 0 {name=x8}
C {component/Inverter/INV.sym} -2010 -1500 0 0 {name=x9}
C {component/Inverter/INV.sym} -1820 -1500 0 0 {name=x16}
C {component/Inverter/INV.sym} -1640 -1500 0 0 {name=x17}
C {component/Inverter/INV.sym} -1720 -1040 0 0 {name=x18}
C {devices/lab_pin.sym} -1030 -970 0 0 {name=l70 sig_type=std_logic lab=Clkb2}
C {devices/lab_pin.sym} -1440 -1500 2 0 {name=l71 sig_type=std_logic lab=Clkb2}
C {devices/lab_pin.sym} -1910 -1670 0 0 {name=l72 sig_type=std_logic lab=Inv}
C {devices/lab_pin.sym} -500 -530 2 0 {name=l73 sig_type=std_logic lab=Clk}
C {devices/lab_pin.sym} -1250 -530 0 0 {name=l74 sig_type=std_logic lab=Clk}
C {devices/lab_pin.sym} -920 -1990 2 0 {name=l75 sig_type=std_logic lab=Vdd}
C {devices/lab_pin.sym} -560 -1660 1 0 {name=l76 sig_type=std_logic lab=O1+}
C {devices/lab_pin.sym} -1280 -1680 1 0 {name=l77 sig_type=std_logic lab=O1-}
C {devices/lab_pin.sym} -2280 -1500 1 0 {name=l78 sig_type=std_logic lab=Clk}
C {devices/lab_pin.sym} -1470 -1040 2 0 {name=l79 sig_type=std_logic lab=Clkb1}
C {devices/lab_pin.sym} -1010 -1920 0 0 {name=l80 sig_type=std_logic lab=Clkb1}
C {devices/lab_pin.sym} -920 -1330 3 0 {name=l81 sig_type=std_logic lab=Clk}
C {devices/iopin.sym} -30 -630 2 1 {name=p1 lab=Out+}
C {devices/iopin.sym} 10 -600 2 1 {name=p4 lab=Out+}
